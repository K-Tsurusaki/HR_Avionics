# Repository K-Tsurusaki/HR_Avionics

File README.md:

# HR_Avionics
Hybrid Rocket Avionics

## KiCad design hardware/REV2/Board2/HR_Avionics_REV2_Board2.kicad_pcb

Parts:
C1: 16SEPF1000M; CP_Radial_D10.0mm_P5.00mm
C2, C3: 16SKV100M6.3X5.5; CP_Elec_6.3x5.4
C7, C8: 4.7u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C9: 3.3u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C17, C18, C20, C21, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C36, C37, C38, C41, C42, C43, C44, C45, C47, C49, C50, C51, C52, C53: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C23, C35, C48: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39, C40: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C46: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D10: NUP2105L; SOT-23
D11: SMBJ16CA(576-SMBJ16CA); D_SMB; not fitted
D13: MA10EB045; D_SOD-123
D15, D16: D_Schottky_Small; D_SOD-123
F2: 1210L300SLWR; Fuse_1210_3225Metric_Pad1.42x2.65mm_HandSolder
FB1: MI0805K601R-10; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
FB3: 782639601; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FL1: DLW32SH101XF2L; FIL_DLW32SH101XF2L; PARTREV N/A
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
IC2, IC3: XC8114AA01PR-G; XC6901D901PRG; Manufacturer_Part_Number XC8114AA01PR-G
J1: 5077CR-16SMC2-BK-TR; NELTRON_5077CR-16SMC2-BK-TR; PARTREV B
J5, J7: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J6: Conn_01x02_Socket; JST_VH_B2PS-VH_1x02_P3.96mm_Horizontal
J9, J12: Conn_01x03_Socket; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J10: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J15, J16, J17, J18: S2711-46R
L1: BLM18PG471SN1D; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1: TJ60S04M3L(T6L,1NQ; TO-252-2
Q8: BSS138; SOT-23
R1: 0; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R5, R7, R10, R11, R14: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R8, R9, R12, R16: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R15: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S2, S3, S4: SS12SDP2; Mouser Part Number 633-SS12SDP2
SW1: PTS645SK50SMTR92LFS; SW4_PTS645SK50SMTR92LFS_CNK
U1: LSM6DSK320XTR; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y
U2: BMP585; LGA9_BMP585_BOS-M
U3: STM32H523RETx; LQFP-64_10x10mm_P0.5mm
U4: MAX-M10S; ublox_MAX
U5, U6: E22-900T30D_E220-900T22S(JP)_versatile
U7, U20, U21: MB85RS4MTYPF-G-BCERE1; SOIC-8_5.3x5.3mm_P1.27mm
U8, U9: TC7S14F; TSOT-23-5_HandSoldering
U10: ASGPDF254.A
U11: M78AR05-1/M78AR033-1; M78AR05-1_M78AR033-1
U12: UGCM1205XP
U13: ADP151AUJZ-3.3; TSOT-23-5
U14: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering
U15: S01-30300500
U16: FT230XS; SSOP-16_3.9x4.9mm_P0.635mm
U17: USBLC6-2SC6; SOT-23-6
U18: TCAN3414DR; SOIC-8_3.9x4.9mm_P1.27mm
U19: USBLC6-4SC6; SOT-23-6

Connections:
3.3V: C20.1, U18.3 (VCC)
+3.3V: C9.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C52.1, C53.1, D15.2 (A), FB3.1, J10.1, R10.2, R11.2, R14.2, S4.3 (NO), U1.5 (VDDIO), U1.8 (VDD), U2.4 (VDDIO), U2.8 (VDD), U3.1 (VBAT), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U7.8 (VDD), U8.5 (VCC), U9.5 (VCC), U11.3 (VOUT), U14.6 (VDDIO), U14.8 (VDD), U19.5 (VBUS), U20.8 (VDD), U21.8 (VDD); also elsewhere on the board
+3.3V_GNSS: C23.2, C25.1, C26.1, D16.2 (A), R7.1, U4.6 (V_BCKP), U4.7 (VCC_IO), U4.8 (VCC), U13.5 (VOUT)
+5V: C2.1, C3.1, C8.1, C21.2, C22.2, C34.1, C35.1, C36.1, C49.2, D13.1 (K), D15.1 (K), D16.1 (K), IC2.5 (VOUT), IC3.5 (VOUT), U5.6 (VCC), U6.6 (VCC), U11.1 (VIN), U12.1 (VIN), U13.1 (VIN), U13.3 (EN)
/BMP585_INT: U2.5 (INT)
/BUZZER_EN: R4.1; also elsewhere on the board
/CAN_RX: U18.4 (RXD)
/CAN_TX: U18.1 (TXD)
/FLIGHT_PIN1: U8.4, U9.4; also elsewhere on the board
/GNSS_EXTINT: R1.1
/GNSS_TIMEPULSE: U4.4 (TIMEPULSE)
/LORA1_AUX: U5.5 (AUX)
/LORA1_M0: U5.1 (M0)
/LORA1_M1: U5.2 (M1)
/LORA2_AUX: U6.5 (AUX)
/LORA2_M0: U6.1 (M0)
/LORA2_M1: U6.2 (M1)
/LSM_INT1: U1.4 (INT1)
/LSM_INT2: U1.9 (INT2)
/SPI1_MISO: U1.1 (SDO/TA0)
/SPI1_MOSI: U1.14 (SDA)
/SPI1_SCK: U1.13 (SCL)
/SPI2_MISO: U2.3 (SDO)
/SPI2_MOSI: U2.2 (SDX)
/SPI2_SCK: U2.1 (SCX)
/SPI3_MISO: U14.5 (SDO)
/SPI3_MOSI: U14.3 (SDI)
/SPI3_SCK: U14.4 (SCK)
/SPI4_MISO: U7.2 (SO), U20.2 (SO), U21.2 (SO)
/SPI4_MOSI: U7.5 (SI), U20.5 (SI), U21.5 (SI)
/SPI4_SCK: U7.6 (SCK), U20.6 (SCK), U21.6 (SCK)
/SWCLK: J10.2, U19.1 (I/O1)
/SWDIO: J10.4, U19.3 (I/O2)
/SWO: J10.6, U19.6 (I/O4)
/UART4_MISO: U4.2 (TXD), U16.1 (TXD)
/UART4_MOSI: U4.3 (RXD), U16.4 (RXD)
/USART1_MISO: U5.4 (TXD)
/USART1_MOSI: U5.3 (RXD)
/USART2_MISO: U6.4 (TXD)
/USART2_MOSI: U6.3 (RXD)
/~FRAM1_CS: U7.1 (~CS)
/~FRAM1_WP: U7.3 (~WP)
/~FRAM2_CS: U20.1 (~CS)
/~FRAM2_WP: U20.3 (~WP)
/~FRAM3_CS: U21.1 (~CS)
/~FRAM3_WP: U21.3 (~WP)
/~GNSS_RESET: R7.2, U4.9 (~RESET)
/~NRST: J10.5, R14.1, R15.2, SW1.1, SW1.2, U19.4 (I/O3)
/~SPI1_CS: U1.12 (CS)
/~SPI2_CS: U2.7 (CSB)
/~SPI3_CS: U14.2 (CSB)
GND: C1.2, C2.2, C3.2, C7.2, C8.2, C9.2, C17.1, C18.1, C21.1, C22.1, C23.1, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.1, C38.1, C39.2, C40.2, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.2, C53.2, D11.1 (A1), IC2.1 (VSS), IC2.2 (EP_1), IC2.6 (EP_2), IC2.7 (EP_3), IC3.1 (VSS), IC3.2 (EP_1), IC3.6 (EP_2), IC3.7 (EP_3), J1.A1_B12 (GND), J1.B1_A12 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J5.2, J6.2, J7.2, J10.3, Q8.2 (S), R5.2, R17.1, R18.1, S3.1 (NC), S4.1 (NC), SW1.3, SW1.4, U1.2 (SDx), U1.3 (SCx), U1.6 (GND), U1.7 (GND), U2.6 (VSS), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U4.1 (GND), U4.10 (GND), U4.12 (GND), U5.7 (GND), U5.8 (GND), U5.9 (GND), U5.10 (GND), U5.11 (GND), U6.7 (GND), U6.8 (GND), U6.9 (GND), U6.10 (GND), U6.11 (GND), U7.4 (VSS), U8.3 (GND), U9.3 (GND), U10.2 (GND), U10.3 (GND), U10.4 (GND), U10.5 (GND), U10.6 (GND), U10.7 (GND), U10.8 (GND), U10.9 (GND), U11.2 (GND), U13.2 (GND), U14.1 (GND), U14.7 (GND), U16.5 (GND), U16.13 (GND), U17.2 (GND), U19.2 (GND), U20.4 (VSS), U21.4 (VSS); also elsewhere on the board
GNDPWR: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J15.1 (Pin_1_1), J16.1 (Pin_1_1), J17.1 (Pin_1_1), J18.1 (Pin_1_1)
GNDS: C20.2, D10.3 (A), J9.3, J12.3, U18.2 (GND), U18.5 (SHDN), U18.8 (STB)
unnamed: C24.2, L1.1, R2.2
unnamed: C37.2, R9.2, U8.2
unnamed 56: C38.2, R12.2, U9.2; also elsewhere on the board
unnamed: C39.1, U3.62 (VCAP)
unnamed: C40.1, U3.30 (VCAP)
unnamed: D11.2 (A2), J6.1, Q1.3 (S), R3.1
unnamed: D13.2 (A), Q8.3 (D), U12.2 (GND)
unnamed: F2.1, J1.A4_B9 (VBUS), J1.B4_A9 (VBUS)
unnamed: C1.1, C7.1, C17.2, IC2.3 (EN), IC2.4 (VIN), Q1.2 (D)
unnamed: J1.A5 (CC1), R18.2
unnamed: J1.B5 (CC2), R17.2
unnamed: J1.A7 (DN1), J1.B7 (DN2), U17.3 (I/O2)
unnamed: J1.A6 (DP1), J1.B6 (DP2), U17.1 (I/O1)
unnamed: J5.1, R9.1, R10.1
unnamed: J7.1, R11.1, R12.1
unnamed: D10.2 (K), FL1.2, J9.1, J12.1, S2.1 (NC)
unnamed 70: D10.1 (K), FL1.3, J9.2, J12.2, R6.2; also elsewhere on the board
unnamed: Q1.1 (G), R3.2, R8.1
unnamed 72: Q8.1 (G), R4.2, R5.1; also elsewhere on the board
unnamed 73: R6.1, S2.2 (COM); also elsewhere on the board
unnamed: R8.2, S3.2 (COM)
unnamed: R13.1, S4.2 (COM)
unnamed: R13.2, U3.60 (BOOT0)
unnamed: R15.1, U3.7 (NRST)
unnamed: C47.2, C48.2, FB3.2, U3.13 (VDDA)
unnamed: R1.2, U4.5 (EXTINT)
unnamed: R2.1, U4.14 (VCC_RF)
unnamed: L1.2, U4.11 (RF_IN), U10.1 (ANT)
unnamed: C50.2, R16.2, U16.3 (VCCIO), U16.10 (3V3OUT)
unnamed: U16.9 (USBDM), U17.4 (I/O2)
unnamed: U16.8 (USBDP), U17.6 (I/O1)
unnamed: R16.1, U16.11 (~RESET)
unnamed: F2.2, FB1.1, U17.5 (VBUS)
unnamed: FL1.1, U18.7 (CANH)
unnamed: FL1.4, U18.6 (CANL)
VBUS: C18.2, C51.2, FB1.2, IC3.3 (EN), IC3.4 (VIN), U16.12 (VCC)

Notes on the sheet:
System Diagram
電源回路
フライトピン
Board2
記憶装置
ブザー
MCU
IC3はUSB給電時用でソフトスタート機能も兼ねる IC2とIC3で理想ダイオードOR．
USB
センサ
Power Supply Diagram
LED
S2711-46R
ねじ穴・シールド
5V以上は印加しない

Board: 4 copper layers, 118 parts (0 on the bottom side), 55 nets, no tracks yet.

Other parts of the board:
R34: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R47: 1k; R_0603_1608Metric
R48: 47k; R_0603_1608Metric
U9#2: TC7S14F; TSOT-23-5_HandSoldering

Their connections:
+3.3V: U9#2.5 (VCC); also elsewhere on the board
/BUZZER_EN: R47.1; also elsewhere on the board
/FLIGHT_PIN1: U9#2.4; also elsewhere on the board
GND: R48.2, U9#2.3 (GND); also elsewhere on the board
unnamed 56: U9#2.2; also elsewhere on the board
unnamed 70: R34.1; also elsewhere on the board
unnamed 72: R47.2, R48.1; also elsewhere on the board
unnamed 73: R34.2; also elsewhere on the board
