# Repository K-Tsurusaki/HR_Avionics (continued)

## KiCad design hardware/REV2/Board1/HR_Avionics_REV2_Board1.kicad_pcb

Parts:
C1, C4, C10, C19: 22u(C2012X5R1V226M125AC); C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 22u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C3: Cin2; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C5, C6, C8, C13, C14, C16, C18, C20, C22, C24: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C9: 56n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11: 25PFV100M6.3X8; CP_Elec_6.3x7.7
C12, C17, C27, C60: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21, C26: 35PFV47M6.3X6.1; CP_Elec_6.3x5.9
C23, C25: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C39: Cin; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C40: Cinx; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C41: Cboot; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C43, C44: Cout; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1, D2: MMSZ5247C-HE3_A-08; D_SOD-123
D3, D5, D6, D9, D11, D17, D18: SMBJ16CA(576-SMBJ16CA); D_SMB
D4, D8: MA10EB045; Vishay_SMPA
D10: NUP2105L; SOT-23
D14, D19, D20: LED_Small; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D15: D_Schottky_Small; D_SOD-123
D16: SMBJ14CA; D_SMB
F1, F2, F7, F8: 1812L300/24SLER; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
F3, F5, F6: SMD1210B150TFT; Fuse_1210_3225Metric_Pad1.42x2.65mm_HandSolder
FB3: 782639601; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FL1: DLW32SH101XF2L; FIL_DLW32SH101XF2L; PARTREV N/A
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1, J2, J6, J11: Conn_01x02_Socket; JST_VH_B2PS-VH_1x02_P3.96mm_Horizontal
J3, J4, J5, J8, J10: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J7: Conn_01x06_Socket; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J9, J12: Conn_01x03_Socket; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J15, J16, J17, J18: S2711-46R
L1: IHLP3232DZER6R8M11; INDPM8682X400N
Q1, Q2, Q3, Q4, Q9, Q10: TJ60S04M3L(T6L,1NQ; TO-252-2
Q5, Q6, Q7, Q8: MTB7D0N06RJ3; TO-252-2
Q11, Q12, Q13: BSS138; SOT-23
R1, R7, R12, R13, R14, R15, R17, R19, R21, R24, R31, R32, R48, R49, R50: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R6, R8, R25, R28, R30, R43, R44, R45, R46, R47, R70: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: Rfbt; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R27, R33: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: LTR100LJZPFU10L0; RESC3264X70N; Mouser Part Number 755-LTR100LJZPFU10L0
R10, R11: RN73H1JTTD10R0F25; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R18, R20, R22: 240; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23, R26: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 1~4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R52: Rfbb; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
S1, S2, S3: SS12SDP2; Mouser Part Number 633-SS12SDP2
U1: LTC4353; MSOP-16_3x4.039mm_P0.5mm
U2: AZ1117CH-3.3TRG1; SOT-223_DIO
U3, U9: MCP1402T-E_OT; SOT95P270X145-5N
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U5, U6: SSM6J808RLF; TSOP6F_TOS-M
U7: INA219AIDR; SOIC-8_3.9x4.9mm_P1.27mm
U8: LMR51635; SOT-23-6
U10: S01-30300500
U16: USBLC6-4SC6; SOT-23-6
U18: TCAN3414DR; SOIC-8_3.9x4.9mm_P1.27mm
Y2: CSTNE16M0V530000R0; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
3.3V: C2.1, C5.1, C13.2, C14.2, C15.2, C20.1, D15.2 (A), FB3.1, J7.1, R19.2, R21.2, R29.1, R31.1, R32.1, R43.2, R44.2, R70.2, U2.2 (OUTPUT), U2.4 (EPAD(OUTPUT)), U4.1 (VDD), U4.17 (VDD), U7.5 (VS), U16.5 (VBUS), U18.3 (VCC)
5V: C42.1, C43.1, C44.1, C60.1, D15.1 (K), L1.2, R3.1, U2.3 (INPUT), U5.1 (D), U5.2 (D), U5.5 (D), U5.6 (D)
/CAN_RX: U4.21 (PA11), U18.4 (RXD)
/CAN_TX: U4.22 (PA12), U18.1 (TXD)
/I2C1_SCL: R31.2, U4.29 (PB6), U7.4 (SCL)
/I2C1_SDA: R32.2, U4.30 (PB7), U7.3 (SDA)
/LED_1: R45.2, U4.18 (PA8)
/LED_2: R46.2, U4.19 (PA9)
/LED_3: R47.2, U4.20 (PA10)
/LTC4353_ONST1: R20.1, U4.11 (PA5)
/LTC4353_ONST2: R22.1, U4.12 (PA6)
/NRST: C18.2, J7.5, R28.2, R29.2, U16.4 (I/O3)
/PWM_SEP1: R27.1, U3.3 (IN), U4.14 (PB0)
/PWM_SEP2: R33.1, U4.15 (PB1), U9.3 (IN)
/SWCLK: J7.2, U4.24 (PA14), U16.1 (I/O1)
/SWDIO: J7.4, U4.23 (PA13), U16.3 (I/O2)
/SWO: J7.6, U4.26 (PB3), U16.6 (I/O4)
/~LTC4353_EN1: R16.2, U4.9 (PA3)
/~LTC4353_EN2: R18.2, U4.10 (PA4)
GNDPWR: C2.2, C3.2, C5.2, C8.1, C11.2, C12.2, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C39.2, C40.2, C42.2, C43.2, C44.2, C60.2, D3.2 (A2), D5.2 (A2), D6.2 (A2), D9.1 (A1), D10.3 (A), D11.1 (A1), D16.1 (A1), D17.1 (A1), D18.2 (A2), H1.1, H2.1, H3.1, H4.1, J1.2, J2.2, J5.2, J6.2, J7.3, J8.2, J9.3, J10.2, J11.2, J12.3, J15.1, J16.1, J17.1, J18.1, Q7.3 (S), Q8.3 (S), Q11.2 (S), Q12.2 (S), Q13.2 (S), R4.2, R5.2, R6.2, R14.1, R15.1, R23.2, R25.1, R26.2, R27.2, R30.2, R33.2, R48.2, R49.2, R50.2, R52.2, S1.1 (NC), S3.1 (NC), U1.15 (GND), U2.1 (ADJ/GND), U3.1 (GND), U3.4 (GND), U4.16 (VSS), U4.32 (VSS), U7.1 (A1), U7.2 (A0), U7.6 (GND), U8.4 (GND), U9.1 (GND), U9.4 (GND), U16.2 (GND), U18.2 (GND), U18.5 (SHDN), U18.8 (STB), Y2.2
unnamed: C11.1, F3.2, F5.2, F6.2, U6.1 (D), U6.2 (D), U6.5 (D), U6.6 (D)
unnamed: C1.2, D1.2 (A), Q1.1 (G), Q2.1 (G), R1.2, R2.1
unnamed: C1.1, D1.1 (K), Q1.3 (S), Q2.3 (S), R1.1
unnamed: C4.2, D2.2 (A), Q3.1 (G), Q4.1 (G), R7.2, R8.1
unnamed: C4.1, D2.1 (K), Q3.3 (S), Q4.3 (S), R7.1
unnamed: C26.1, D3.1 (A1), D8.1 (K), F2.1, J4.1
unnamed: D4.2 (A), D5.1 (A1), J3.2, Q7.2 (D)
unnamed: D6.1 (A1), D8.2 (A), J4.2, Q8.2 (D)
unnamed: D9.2 (A2), F7.1, J6.1
unnamed: D11.2 (A2), F8.1, J11.1
unnamed: D14.2 (A), R70.1
unnamed: D14.1 (K), Q11.3 (D)
unnamed: D16.2 (A2), J1.1, Q2.2 (D)
unnamed: D17.2 (A2), J2.1, Q3.2 (D)
unnamed: C21.1, D4.1 (K), D18.1 (A1), F1.1, J3.1
unnamed: D19.2 (A), R43.1
unnamed: D19.1 (K), Q12.3 (D)
unnamed: D20.2 (A), R44.1
unnamed: D20.1 (K), Q13.3 (D)
unnamed: F3.1, J5.1
unnamed: F6.1, J8.1
unnamed: F5.1, J10.1
unnamed: D10.2 (K), FL1.2, J9.1, J12.1, S2.1 (NC)
unnamed: D10.1 (K), FL1.3, J9.2, J12.2, R34.1
unnamed: C12.1, C27.1, Q5.2 (D), Q6.2 (D), R9.1, R10.1, U1.7 (OUT2), U1.10 (OUT1)
unnamed: Q5.1 (G), U1.12 (GATE1)
unnamed: Q6.1 (G), U1.5 (GATE2)
unnamed: Q7.1 (G), R4.1, U3.5 (OUT)
unnamed: Q8.1 (G), R5.1, U9.5 (OUT)
unnamed: F7.2, F8.2, Q10.2 (D)
unnamed: C19.2, Q9.1 (G), Q10.1 (G), R6.1, R12.2
unnamed: C19.1, Q9.3 (S), Q10.3 (S), R12.1
unnamed: Q11.1 (G), R45.1, R48.1
unnamed: Q12.1 (G), R46.1, R49.1
unnamed: Q13.1 (G), R47.1, R50.1
unnamed: R8.2, S1.2 (COM)
unnamed: R34.2, S2.2 (COM)
unnamed: R2.2, S3.2 (COM)
unnamed: C7.1, U1.11 (CPO1)
unnamed: C9.1, U1.6 (CPO2)
unnamed: C8.2, U1.14 (VCC)
unnamed: R14.2, R16.1, U1.16 (~EN1)
unnamed: R15.2, R18.1, U1.1 (~EN2)
unnamed: R19.1, R20.2, U1.9 (~ONST1)
unnamed: R21.1, R22.2, U1.8 (~ONST2)
unnamed: R30.1, U4.31 (BOOT0)
unnamed: R28.1, U4.4 (NRST)
unnamed: R13.2, R23.1, U4.7 (PA1)
unnamed: R17.2, R26.1, U4.8 (PA2)
unnamed: U4.2 (PF0), Y2.3
unnamed: U4.3 (PF1), Y2.1
unnamed: C16.2, C17.2, FB3.2, U4.5 (VDDA)
unnamed: C10.2, R24.2, R25.2, U5.3 (G), U6.3 (G)
unnamed: C10.1, R24.1, U5.4 (S), U6.4 (S)
unnamed: C6.1, R10.2, U7.8 (IN+)
unnamed: C6.2, R11.2, U7.7 (IN-)
unnamed: C41.1, U8.6 (CB)
unnamed: R3.2, R52.1, U8.1 (FB)
unnamed: C41.2, L1.1, U8.5 (SW)
unnamed: FL1.1, U18.7 (CANH)
unnamed: FL1.4, U18.6 (CANL)
VBATT: C7.2, Q1.2 (D), Q5.3 (S), R13.1, U1.13 (VIN1)
VDC: C3.1, C22.1, C23.1, C24.1, C25.1, C39.1, C40.1, F1.2, F2.2, Q9.2 (D), R9.2, R11.1, U3.2 (VDD), U8.2 (EN), U8.3 (VIN), U9.2 (VDD)
VEX: C9.2, Q4.2 (D), Q6.3 (S), R17.1, U1.4 (VIN2)

Notes on the sheet:
電源出力
Value=Cout PartNum=GRM32ER61C476KE15L Cap=47uF VDC=16 V ESR=3.04 mΩ
11.1V from LiPo battery
外部接続（通信）
ニクロム駆動回路
ソフトスタート用
降圧回路
MCU
5VDCDCコンバータ
電源切り替え回路
PartNum=IHLP3232DZER6R8M11 L=6.8 µH DCR=33.4 mΩ IDC=6.7 A
Value=Cinx PartNum=Undefined Cap=100 nF VDC=22.5 V ESR=1 µΩ
I2C_ADDR: 0x40
Value=Rfbt R=100 kΩ Tolerance=1.0%
Value=Cin2 PartNum=KGM32AR71H106KL Cap=10 µF VDC=50 V
14V from ground power equipment
Value=Cin PartNum=GRM31CR71H475KA12L Cap=4.7 µF VDC=50 V ESR=3 mΩ
Value=Cboot PartNum=C0603C104J3RAC Cap=100 nF VDC=16 V ESR=1 mΩ
- ~{LTC4353_EN1}及び~{LTC4353_EN2}は電源ソースを能動的に 選択するためのピン．負論理であるからLowにした時に有効化される． 両方とも同時にHighにしてはならない．デフォルトではプルダウン されているため理想ダイオードORとして動作する． - LTC4353_ONST1とLTC4353_ONST2はFETのON/OFF状態をMCUに通知する．
S2711-46R
Input=6-15VDC Output=5V(3A) Vout Tolerance=3.22% Switching Frequency=400kHz Steady state efficiency=95.1%
STM32側でのGPIOの プルアップ設定はしない!
LED
バッテリ電圧と外部供給電圧を監視するための分圧抵抗
11.1V - 14.8V
Value=Rfbb R=19.1 kΩ Tolerance=1.0% PartNum=AC0603FR-0719K1L

Board: 4 copper layers, 100.0 x 50.0 mm, 154 parts (69 on the bottom side), 84 nets.
